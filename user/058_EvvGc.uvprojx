# Keil uVision project 058_EvvGc.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 058_EvvGc
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\src\VCP\inc;..\src\sys;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32_USB-FS-Device_Driver\inc;..\CORE;..\src
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group EVVGC
    ../src/: adc.c comio.c commhandler.c config.c eeprom.c engine.c fasttrig.c gyro.c i2c.c pins.c pwm.c rc.c reboot.c ringbuffer.c stopwatch.c systick.c usart.c usb.c utils.c system_stm32f10x.c stm32_it.c
    ../src/VCP/src/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
    ../src/sys/: itoa.c printf.c
  group FWLib
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group USER
    ../src/: main.c
  group USB_FWLib
    ../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
